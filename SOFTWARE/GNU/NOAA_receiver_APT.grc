options:
  parameters:
    author: psycoXx
    category: Custom
    generate_options: qt_gui
    id: noaa_receiver
    output_language: python
    title: NOAA Receiver
  states: {}

blocks:
- name: audio_sample_rate
  id: variable
  parameters:
    value: 11.025e3
  states: {}
- name: center_freq
  id: variable_qtgui_chooser
  parameters:
    label0: NOAA-19
    label1: NOAA-15
    label2: NOAA-18
    num_opts: '3'
    option0: 137.1e6
    option1: 137.62e6
    option2: 137.9125e6
    type: real
    value: 137.1e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '30'
    step: '5'
    stop: '50'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: WavToImg_0
  id: WavToImg
  parameters:
    samp_rate_audio: audio_sample_rate
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: 96e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '6.5'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: notebook_rf
  id: qtgui_tab_widget
  parameters:
    gui_hint: notebook_top@0
    label0: Spectrum
    label1: Waterfall
    num_tabs: '2'
  states: {}
- name: notebook_top
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2, 0, 1, 2
    label0: RF
    label1: Audio
    num_tabs: '2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: notebook_rf@0
    legend: 'False'
    showports: 'True'
    type: complex
    ymax: '-20'
    ymin: '-80'
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '2'
    name: Image APT
    ncols: '5000'
    nrows: '900'
    samp_rate: 10e3
    type: float
    zmax: '0.4'
    zmin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: notebook_rf@1
    int_max: '-20'
    int_min: '-80'
    legend: 'False'
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '192'
    interp: '441'
    type: fff
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    corr0: '9'
    dc_offset_mode0: '2'
    freq0: center_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [WavToImg_0, '0', qtgui_time_raster_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', WavToImg_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', rational_resampler_xxx_2, '0']
- [rational_resampler_xxx_2, '0', blocks_multiply_const_vxx_1, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
