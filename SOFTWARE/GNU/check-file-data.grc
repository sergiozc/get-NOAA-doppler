options:
  parameters:
    generate_options: qt_gui
    id: check_file
    output_language: python
    title: check-file-data
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 137.1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Usuario\Desktop\SEI\GNU RADIO\rtl-data.dat
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    rate: '5'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
