options:
  parameters:
    author: psycoXx
    generate_options: qt_gui
    id: rtl_capture
    output_language: python
    title: SDR CAPTURE
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: frecuencia central
    outputmsgname: value
    showports: 'False'
    start: 100e6
    step: 100e3
    stop: 200e6
    value: 137.1e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 104.5e6
  states: {state: disabled}
- name: gain
  id: variable
  parameters:
    value: '45'
  states: {state: disabled}
- name: gain
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '30'
    step: '5'
    stop: '50'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Usuario\Desktop\SEI\PROYECTO\get-sat-project\SOFTWARE\GNU\NOAA-data.dat
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    rate: '5'
    showrf: 'True'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    corr0: '20'
    freq0: center_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
